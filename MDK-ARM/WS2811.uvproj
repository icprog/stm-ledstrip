# Keil uVision project WS2811.uvproj, settings and files
target WS2811-F1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: WS2811
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_MD USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: .\inc;D:\Keil\ARM\RV31\LIB\ST\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ./: main.c startup_stm32f4xx.s system_stm32f4xx.c startup_stm32f10x_md.s system_stm32f10x.c
  group STM32F4 Std Lib
    D:/Keil/ARM/RV31/LIB/ST/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c
target WS2811-F4 (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: WS2811
  c flags: Optim=1 OneElfS=1
  c define: STM32F4XX USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: .\inc;D:\Keil\ARM\RV31\LIB\ST\STM32F4xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
